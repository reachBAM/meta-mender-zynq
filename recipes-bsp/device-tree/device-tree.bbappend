RPROVIDES_${PN} = "kernel-devicetree"

